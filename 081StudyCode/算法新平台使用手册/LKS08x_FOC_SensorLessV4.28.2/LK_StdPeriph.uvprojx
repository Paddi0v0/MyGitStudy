# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 08x Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC081C8T8 Linko
  pack: Linko.LKS08x.1.1.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS_MC_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Include;.\LKS32MC08x_Periph_Driver\Include;.\Kernal_Source;.\LKS_VIEWER;.\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group AppFunction
    ./AppFunction/: Global_Variable.c hardware_init.c interrupt.c System_Init.c Task_Scheduler.c state_machine.c fault_detection.c Process_Control.c PowerCalculation.c SpeedScan.c
  group Kernel_Code
    ./Kernal_Source/: main.c MC_math.c App2Core.c FOC_Drive.c SignalChain_Sample.c PID_regulators.c MC_hall.c LKS08x_FluxOBS_Hall_V4p2.lib bemf_check0824.o
  group Periph_Driver
    ./LKS32MC08x_Periph_Driver/Source/: lks32mc08x_adc.c lks32mc08x_can.c lks32mc08x_cmp.c lks32mc08x_dac.c lks32mc08x_dma.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32MC08x_flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_iwdg.c lks32mc08x_mcpwm.c lks32mc08x_opa.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c lks32mc08x_tmp.c lks32mc08x_nvr.lib startup_lks32mc08x.s
  group SEGGER_RTT
    ./SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Include
    ./Include/: function_config.h hardware_config.h MC_Parameter.h
software components: CMSIS:CORE 5.5.0
