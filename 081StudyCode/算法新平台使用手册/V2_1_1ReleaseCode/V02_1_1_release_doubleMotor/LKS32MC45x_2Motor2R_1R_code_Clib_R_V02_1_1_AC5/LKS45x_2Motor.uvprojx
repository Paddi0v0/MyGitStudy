# Keil uVision project LKS45x_2Motor.uvprojx, settings and files
target Linko_45x_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC453RCT8 Linko
  pack: Linko.LKS45x.1.1.6
  cpu: IRAM(0x20000000,0xA000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lks45x_Project +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: .\3_CommonServiceLayer\Header;.\Include;.\1_LKS_FwLib\LKS32MC45x_Periph_Driver\Include;.\5_MotorAppLayer\Header;.\4_MotorDriveLayer\Header;.\6_UserAppLayer\Header;.\Include;.\RTT;.\2_HardwareDriverLayer\Header;.\5_MotorAppLayer\usr\Header
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3fc00
  memory RVCT5: ROM 0x3fc00 size 0x400
  memory RVCT9: RAM 0x20000000 size 0xa000
  group 1_LKS_FwLib
    ./1_LKS_FwLib/LKS32MC45x_Periph_Driver/Source/: lks32mc45x_adc.c lks32mc45x_can.c lks32mc45x_cmp.c lks32mc45x_cordic.c lks32mc45x_crc.c lks32mc45x_dma.c lks32mc45x_flash.c lks32mc45x_fmac.c lks32mc45x_gpio.c lks32mc45x_hall.c lks32mc45x_i2c.c lks32mc45x_iwdg.c lks32mc45x_mcpwm.c lks32mc45x_qep.c lks32mc45x_spi.c lks32mc45x_sys.c lks32mc45x_uart.c lks32mc45x_utimer.c lks32mc45x_wwdg.c startup_lks32mc45x.s lks32mc45x_afe.c lks32mc45x_aon.c lks32mc45x_nvr.c lks32mc45x_trim.s
  group 2_HardwareDriverLayer
    ./2_HardwareDriverLayer/HardwareDriver/: hardware_init.c interrupt.c main.c System_Init.c HAL_DEF.c
  group 3_CommonServiceLayer
    ./3_CommonServiceLayer/: ComFuncs.c PubData_DriverInstance.c PubData_HD_MD.c PubData_MA_UA.c PubData_MD_MA.c MC_math.c
  group 4_MotorDriveLayer
    ./4_MotorDriveLayer/: FOC_Drive.c FocDef.c PID_regulators.c
    ./4_MotorDriveLayer/Lib/: lks45x_Lib_R_V02_1_0a0Opt_2Motor.lib
  group 5_MotorAppLayer
    ./5_MotorAppLayer/: Main_Drive.c PowerCalculation.c Process_Control.c state_machine.c MA_Static_Variable.c MA_interface.c
    ./5_MotorAppLayer/usr/: Task_Scheduler.c fault_detection.c
  group 6_UserAppLayer
    ./6_UserAppLayer/: UA_interface.c UA_stateMachine.c UA_usrApp.c
  group Include
    ./Include/: MC_Parameter_M0.h MC_Parameter_M1.h MC_configure_FB_data.h project_config.h MC_GlobalDef_M0.h MC_GlobalDef_M1.h project_mcu.h hardware_config.h
  group RTT_debug
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h
software components: CMSIS:CORE 5.3.0
