# Keil uVision project LKS08x_1Motor.uvprojx, settings and files
target Linko_08x_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC081C8T8 Linko
  pack: Linko.LKS08x.1.1.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks08x_Project +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c include: .\3_CommonServiceLayer\Header;.\Include;.\5_MotorAppLayer\Header;.\4_MotorDriveLayer\Header;.\6_UserAppLayer\Header;.\RTT;.\1_LKS_FwLib\LKS32MC08x_Periph_Driver\Include;.\2_HardwareDriverLayer\Header;.\2_HardwareDriverLayer\ClassB;.\5_MotorAppLayer\usr\Header
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfe00
  memory RVCT5: ROM 0xfe00 size 0x200
  memory RVCT9: RAM 0x20000000 size 0x2000
  group 1_LKS_FwLib
    ./1_LKS_FwLib/lks32mc08x_periph_driver/Source/: lks32mc08x_adc.c lks32mc08x_can.c lks32mc08x_cmp.c lks32mc08x_dac.c lks32mc08x_DMA.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32MC08x_Flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_iwdg.c lks32mc08x_MCPWM.c lks32mc08x_opa.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_tmp.c lks32mc08x_uart.c startup_lks32mc08x.s lks32mc08x_nvr.lib
  group 2_HardwareDriverLayer
    ./2_HardwareDriverLayer/HardwareDriver/: hardware_init.c interrupt.c main.c System_Init.c HAL_DEF.c
  group 3_CommonServiceLayer
    ./3_CommonServiceLayer/: ComFuncs.c PubData_DriverInstance.c PubData_HD_MD.c PubData_MA_UA.c PubData_MD_MA.c MC_math.c
  group 4_MotorDriveLayer
    ./4_MotorDriveLayer/: FOC_Drive.c FocDef.c PID_regulators.c
    ./4_MotorDriveLayer/Lib/: lks08x_Lib_RV02_1_0a0Opt_AC5.lib
  group 5_MotorAppLayer
    ./5_MotorAppLayer/: Main_Drive.c PowerCalculation.c Process_Control.c state_machine.c MA_Static_Variable.c MA_interface.c
    ./5_MotorAppLayer/usr/: fault_detection.c Task_Scheduler.c
  group 6_UserAppLayer
    ./6_UserAppLayer/: UA_interface.c UA_stateMachine.c UA_usrApp.c
  group Include
    ./Include/: MC_Parameter_M0.h MC_configure_FB_data.h project_config.h
  group RTT_debug
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h
  group CLASS B
    ./2_HardwareDriverLayer/ClassB/: MarchC+.s Ram_scan.s Register_scan.s Software_safe.c Software_safe.h
software components: CMSIS:CORE 5.5.0
