# Keil uVision project LKS03x_1Motor.uvprojx, settings and files
target Linko_03x_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC037M6S8 Linko
  pack: Linko.LKS03x.1.0.7
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks03x_Project +hex
  c flags: oTime=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\1_LKS_FwLib\lks32mc03x_periph_driver\Include;.\2_HardwareDriverLayer\Header;.\3_CommonServiceLayer\Header;.\5_MotorAppLayer\Header;.\4_MotorDriveLayer\Header;.\6_UserAppLayer\Header;.\Include;.\RTT;.\5_MotorAppLayer\usr\Header;.\2_HardwareDriverLayer\ClassB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7e00
  memory RVCT5: ROM 0x7e00 size 0x200
  memory RVCT9: RAM 0x20000000 size 0x1000
  group 1_LKS_FwLib
    ./1_LKS_FwLib/lks32mc03x_periph_driver/Source/: lks32mc03x_adc.c lks32mc03x_cmp.c lks32mc03x_dac.c lks32mc03x_DMA.c lks32mc03x_dsp.c lks32MC03x_Flash.c lks32mc03x_gpio.c lks32mc03x_hall.c lks32mc03x_I2C.c lks32mc03x_IWDG.c lks32mc03x_MCPWM.c lks32mc03x_nvr.lib lks32mc03x_opa.c lks32mc03x_spi.c lks32mc03x_sys.c lks32mc03x_timer.c lks32mc03x_tmp.c lks32mc03x_uart.c startup_lks32mc03x.s
  group 2_HardwareDriveLayer
    ./2_HardwareDriverLayer/HardwareDriver/: HAL_DEF.c hardware_init.c interrupt.c main.c System_Init.c
  group 3_CommonServiceLayer
    ./3_CommonServiceLayer/: ComFuncs.c MC_math.c PubData_DriverInstance.c PubData_HD_MD.c PubData_MA_UA.c PubData_MD_MA.c
  group 4_MotorDriveLayer
    ./4_MotorDriveLayer/: FOC_Drive.c FocDef.c PID_regulators.c
    ./4_MotorDriveLayer/Lib/: lks03x_Lib_R_V02_1_0a0Opt_AC5.lib
  group 5_MotorAppLayer
    ./5_MotorAppLayer/: MA_interface.c MA_Static_Variable.c Main_Drive.c PowerCalculation.c Process_Control.c state_machine.c
    ./5_MotorAppLayer/usr/: fault_detection.c Task_Scheduler.c
  group 6_UserAppLayer
    ./6_UserAppLayer/: UA_interface.c UA_stateMachine.c UA_usrApp.c
  group Include
    ./Include/: hardware_config.h MC_configure_FB_data.h MC_GlobalDef_M0.h MC_Parameter_M0.h project_config.h
  group RTT_debug
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group ClassB
    ./2_HardwareDriverLayer/ClassB/: asm_test.s MarchC+.s Ram_addr_test.s Ram_scan.s Register_scan.s Software_safe.c Software_safe.h
software components: CMSIS:CORE 5.5.0
