# Keil uVision project 02_呼吸灯.uvprojx, settings and files
target 02_呼吸灯 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC081C8T8 Linko
  pack: Linko.LKS08x.1.1.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 02_呼吸灯 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\Arm\INC\Linko\LKS32MC08x;.\Drivers\Include;.\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group AppFunction
    ./AppFunction/: hardware_init.c interrupt.c mygpio_init.c
  group DriversInclude
    ./Drivers/Include/: lks32mc08x_adc.h lks32mc08x_can.h lks32mc08x_cmp.h lks32mc08x_dac.h lks32mc08x_DMA.h lks32mc08x_dsp.h lks32mc08x_exti.h lks32MC08x_Flash.h lks32mc08x_gpio.h lks32mc08x_hall.h lks32mc08x_i2c.h lks32mc08x_iwdg.h lks32mc08x_lib.h lks32mc08x_MCPWM.h lks32mc08x_NVR.h lks32mc08x_opa.h lks32mc08x_spi.h lks32mc08x_sys.h lks32mc08x_tim.h lks32mc08x_tmp.h lks32mc08x_uart.h
  group DriversSource
    ./Drivers/Source/: lks32mc08x_adc.c lks32mc08x_can.c lks32mc08x_cmp.c lks32mc08x_dac.c lks32mc08x_DMA.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32MC08x_Flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_iwdg.c lks32mc08x_MCPWM.c lks32mc08x_nvr.lib lks32mc08x_opa.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_tmp.c lks32mc08x_uart.c startup_lks32mc08x.s
  group Include
    ./Include/: hardware_config.h hardware_init.h interrupt.h mygpio_init.h
  group Source
    ./Source/: main.c
