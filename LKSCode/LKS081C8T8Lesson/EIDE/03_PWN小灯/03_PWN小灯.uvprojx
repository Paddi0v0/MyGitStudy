# Keil uVision project 03_PWN小灯.uvprojx, settings and files
target 03_PWN小灯 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 03_PWN小灯
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\..\..\..\Keil_v5\Arm\INC\Linko\LKS32MC08x;Drivers\Include;Include
  library: MicroLIB
  memory RVCT1: RAM 0x0 size 0x8000
  memory RVCT6: RAM 0x20000000 size 0x2000
  group APPFUNCTION
    AppFunction/: hardware_init.c interrupt.c mygpio_init.c mytimer_init.c
  group DRIVERS/SOURCE
    Drivers/Source/: lks32mc08x_adc.c lks32mc08x_can.c lks32mc08x_cmp.c lks32mc08x_dac.c lks32mc08x_DMA.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32MC08x_Flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_iwdg.c lks32mc08x_MCPWM.c lks32mc08x_opa.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_tmp.c lks32mc08x_uart.c startup_lks32mc08x.s
  group SOURCE
    Source/: main.c
  group <virtual_root>
    Drivers/Source/: lks32mc08x_nvr.lib
