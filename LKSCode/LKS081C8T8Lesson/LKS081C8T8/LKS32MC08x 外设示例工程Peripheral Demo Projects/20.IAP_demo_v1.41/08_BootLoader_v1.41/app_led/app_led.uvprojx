# Keil uVision project app_led.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC083C8T8 Linko
  pack: Linko.LKS08x.1.1.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app_led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Drivers\Include
  memory RVCT4: ROM 0xa00 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./APP/: delay.c delay.h interrupt.c main.c
    ./: startup_lks32mc081.s
software components: CMSIS:CORE 5.5.0
