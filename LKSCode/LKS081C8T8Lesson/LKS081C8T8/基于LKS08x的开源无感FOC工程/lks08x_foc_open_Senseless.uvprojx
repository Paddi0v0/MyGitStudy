# Keil uVision project lks08x_foc_open_Senseless.uvprojx, settings and files
target lks08x_foc_open_Senseless (6140000::V6.14::ARMCLANG)
  device: LKS32MC081C8T8 Linko
  pack: Linko.LKS08x.1.1.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks08x_foc_open_Senseless
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\Include;.\periph_driver\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app_function
    ./app_function/: main.c hardware_init.c sys_init.c task_scheduler.c interrupt.c global_variable.c key.c
  group kernal_source
    ./kernal_source/: smo.c foc_drive.c clarke_park.c pid_regulators.c
  group periph_driver
    ./periph_driver/Source/: lks32mc08x_adc.c lks32mc08x_can.c lks32mc08x_cmp.c lks32mc08x_dac.c lks32mc08x_dma.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32MC08x_flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_iwdg.c lks32mc08x_mcpwm.c lks32mc08x_opa.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c startup_lks32mc08x.s lks32mc08x_nvr.lib
  group config
    ./Include/: hardware_config.h mc_type.h
software components: CMSIS:CORE 5.6.0
