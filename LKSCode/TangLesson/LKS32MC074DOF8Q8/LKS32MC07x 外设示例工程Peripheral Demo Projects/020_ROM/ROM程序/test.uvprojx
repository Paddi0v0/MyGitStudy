# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC070RBT8 Linko
  pack: Linko.LKS07x.1.1.2
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x10000 size 0x10000
  memory RVCT9: RAM 0x20002000 size 0x1000
  group Source Group 1
    ./: main.c startup_lks32mc07x.s
    ./rom_program/: lks32mc03x_rom.lib
  group rom_program
    ./rom_program/: program1.c
software components: CMSIS:CORE 5.5.0
