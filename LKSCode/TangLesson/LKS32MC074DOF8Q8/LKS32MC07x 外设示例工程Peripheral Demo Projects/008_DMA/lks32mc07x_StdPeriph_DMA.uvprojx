# Keil uVision project lks32mc07x_StdPeriph_DMA.uvprojx, settings and files
target Lks32mc07x_StdPeriph_DMA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC071CBT8 Linko
  pack: Linko.LKS07x.1.0.5
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks32mc07x_StdPeriph_DMA
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include;.\LKS32MC07x_Periph_Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./Source/: main.c
  group AppFunciton
    ./AppFunction/: interrupt.c hardware_init.c
  group Periph_Drivers
    ./LKS32MC07x_Periph_Driver/Source/: lks32mc07x_dma.c lks32mc07x_gpio.c lks32mc07x_uart.c startup_lks32mc07x.s lks32mc07x_sys.c lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_cmp.c lks32mc07x_dac.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32MC07x_flash.c lks32mc07x_hall.c lks32mc07x_mcpwm.c lks32mc07x_nvr.lib lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_wake.c
software components: CMSIS:CORE 5.0.1
