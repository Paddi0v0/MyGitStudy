# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 07x Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC071C8T8 Linko
  pack: Linko.LKS07x.1.1.2
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS_MC_Project +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Include;.\Kernal_Source;.\LKS32MC07x_Periph_Driver\include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group AppFunction
    ./Kernal_Source/: main.c
    ./AppFunction/: hardware_init.c interrupt.c delay.c
    ./: i2c_eeprom.c
  group Periph_Driver
    ./lks32mc07x_periph_driver/Source/: lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_clu.c lks32mc07x_cmp.c lks32mc07x_crc.c lks32mc07x_dac.c lks32mc07x_dma.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32MC07x_flash.c lks32mc07x_gpio.c lks32mc07x_hall.c lks32mc07x_i2c.c lks32mc07x_mcpwm.c lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_spi.c lks32mc07x_sys.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_uart.c lks32mc07x_wake.c lks32mc07x_nvr.lib startup_lks32mc07x.s
software components: CMSIS:CORE 5.6.0
