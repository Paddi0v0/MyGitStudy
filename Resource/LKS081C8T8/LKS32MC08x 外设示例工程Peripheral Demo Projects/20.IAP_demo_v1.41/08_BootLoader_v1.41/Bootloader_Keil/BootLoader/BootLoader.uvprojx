# Keil uVision project BootLoader.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC083C8T8 Linko
  pack: Linko.LKS08x.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\connie_Driver\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: interrupt.c main.c comdata.c startup_lks32mc08x.s comdata.h hardinit.c hardinit.h
    ../connie_Driver/Source/: lks32MC08x_Flash.c
  group ReadMe
    ./: Readme.txt
software components: CMSIS:CORE 5.5.0
