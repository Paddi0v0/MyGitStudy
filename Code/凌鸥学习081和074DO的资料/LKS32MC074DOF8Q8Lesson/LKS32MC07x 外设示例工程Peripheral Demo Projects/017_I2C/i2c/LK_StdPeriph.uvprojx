# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 07x Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC071CBT8 Linko
  pack: Linko.LKS07x.1.1.2
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LK_StdPeriph +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;.\LKS32MC07x_Periph_Driver\Include;.\i2c_driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./Source/: interrupt.c main.c hardware_init.c
  group Periph_Driver
    ./LKS32MC07x_Periph_Driver/Source/: lks32mc07x_adc.c lks32mc07x_cmp.c lks32mc07x_DMA.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32MC07x_Flash.c lks32mc07x_gpio.c lks32mc07x_hall.c lks32mc07x_i2c.c lks32mc07x_MCPWM.c lks32mc07x_sys.c lks32mc07x_tim.c lks32mc07x_uart.c startup_lks32mc07x.s lks32mc07x_nvr.lib lks32mc07x_crc.c lks32mc07x_clu.c lks32mc07x_can.c lks32mc07x_dac.c lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_tmp.c lks32mc07x_wake.c
  group i2c_driver
    ./i2c_driver/: i2c_driver.c i2c_driver.h
software components: CMSIS:CORE 5.5.0
