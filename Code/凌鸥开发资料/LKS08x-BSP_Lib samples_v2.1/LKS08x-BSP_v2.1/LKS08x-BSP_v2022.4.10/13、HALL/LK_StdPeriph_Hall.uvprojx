# Keil uVision project LK_StdPeriph_Hall.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC081C8T8 Linko
  pack: Linko.LKS08x.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LK_StdPeriph_Hall +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeMaster;.\Include;.\LKS32MC08x_Periph_Driver\Include;.\Source;.\USER\LED;.\USER\KEY;.\USER\Delay;.\USER\UTimer;.\USER\WDT_0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source_Code
    ./Source/: main.c
  group AppFunction
    ./Source/: startup_lks32mc08x.s
    ./AppFunction/: hardware_init.c interrupt.c
  group Periph_Driver
    ./LKS32MC08x_Periph_Driver/Source/: lks32mc08x_adc.c lks32mc08x_cmp.c lks32mc08x_DMA.c lks32mc08x_exti.c lks32MC08x_Flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_MCPWM.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c lks32mc08x_nvr.o lks32mc08x_dsp.c lks32mc08x_opa.c
  group USER
    ./USER/LED/: GPIO_LED.c
    ./USER/KEY/: GPIO_KEY.c
    ./USER/Delay/: delay.c
    ./USER/UTimer/: UTimer.c
    ./USER/WDT_0/: WDT.c
