# Keil uVision project LKS08x_FOC_Open_HallSense.uvprojx, settings and files
target LKS08x_FOC_Open_HallSense (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC081C8T8 Linko
  pack: Linko.LKS08x.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS08x_FOC_Open_HallSense
  c flags: OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: .\Include;.\LKS32MC08x_Periph_Driver\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group AppFunction
    ./AppFunction/: bus_voltage.c external_function.c Global_Variable.c HandlerbarControl.c hardware_init.c interrupt.c main.c multifunctional_pro.c sys_init.c Task_Scheduler.c
  group Kernel_Code
    ./Kernal_Source/: Clarke_Park.c FOC_Drive.c MC_hall.c PID_regulators.c Svpwm.c
  group Periph_Driver
    ./LKS32MC08x_Periph_Driver/Source/: lks32mc08x_adc.c lks32mc08x_can.c lks32mc08x_cmp.c lks32mc08x_dac.c lks32mc08x_dma.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32MC08x_flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_iwdg.c lks32mc08x_mcpwm.c lks32mc08x_opa.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c lks32mc08x_nvr.lib startup_lks32mc08x.s
software components: CMSIS:CORE 5.6.0
