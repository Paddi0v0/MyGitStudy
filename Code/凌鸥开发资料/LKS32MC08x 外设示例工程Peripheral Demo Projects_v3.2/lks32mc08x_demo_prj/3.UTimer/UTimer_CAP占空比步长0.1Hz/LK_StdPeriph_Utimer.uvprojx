# Keil uVision project LK_StdPeriph_Utimer.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC081C8T8 Linko
  pack: Linko.LKS08x.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LK_StdPeriph_Utimer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeMaster;.\Include;.\LKS32MC08x_Periph_Driver\Include;.\Source;.\USER\LED;.\USER\KEY;.\USER\Delay;.\USER\UTimer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source_Code
    ./Source/: main.c
  group AppFunction
    ./AppFunction/: hardware_init.c interrupt.c
  group Periph_Driver
    ./LKS32MC08x_Periph_Driver/Source/: lks32mc08x_adc.c lks32mc08x_can.c lks32mc08x_cmp.c lks32mc08x_dac.c lks32mc08x_dma.c lks32mc08x_dsp.c lks32mc08x_exti.c lks32MC08x_flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_i2c.c lks32mc08x_iwdg.c lks32mc08x_mcpwm.c lks32mc08x_opa.c lks32mc08x_spi.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c lks32mc08x_nvr.lib startup_lks32mc08x.s
    ../UTimer_CAP/LKS32MC08x_Periph_Driver/Source/: lks32mc08x_tmp.c
software components: CMSIS:CORE 5.5.0
